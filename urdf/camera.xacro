Commit message: Con imagenes QR buenas

File: urdf/camera.xacro (robot description, xacro)
@@ -4,5 +4,5 @@
     <parent link="base_link"/>
     <child link="camera_link"/>
-    <origin xyz="0.305 0 0.2" rpy="0 0 0"/>
+    <origin xyz="0.305 0 1" rpy="0 0 0"/>
 </joint>
 <link name="camera_link">
